<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-3-0.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="B5F368E9-62DB-4D8D-8DC2-3C0204F4BB55">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="3EE16B91-94EA-477E-B04B-2090B997FB37">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B0C3662C-43F3-49A1-8665-C64C10C09209">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FECC507C-D946-4CAE-967B-52697EAED7FD">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="32DE880B-E4E8-48E9-9D32-C567CFFEE534">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="ff55d029-386d-43a2-b3c2-dfef4c7a5e36">
      <SHORT-NAME>MICROSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="bacabec4-05bb-41bc-8c85-cc81790aafd5">
          <SHORT-NAME>BswM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="c015ab67-541c-4a5f-a079-598192b126d2">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7c5af284-6918-4403-9b5c-0b126cdaa59d">
          <SHORT-NAME>ComM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="ab22ad15-8c91-4e5b-acc2-8151f177d829">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="7c510a15-9388-44b9-a035-f4330cda38ef">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="2130b876-d50c-4133-a520-27e2d091f7f7">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="d53a6a3c-6ae6-4455-a2b6-cfe904af76e9">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="955c8ed4-a6dd-4b22-87b3-996baf91c24f">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="0dd4805b-0614-49f4-9e6a-12e51e0cf4ae">
          <SHORT-NAME>Det_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="96d3aca7-7473-46fb-8912-30aa72385ddf">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="c4f3aa32-df51-4238-8238-3f8971fb69c8">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2123b1f9-511e-42a9-abe1-a47bfd163d81">
          <SHORT-NAME>EcuM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="006ed213-5f7a-4854-97a8-f4df833cec58">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="81eca216-99dc-49fc-884c-39c3004d6827">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="17a9a469-7f85-4e2c-92e2-bb2dafb2aca9">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="82ef73f8-437d-4ce7-9246-5c2bb4b1f20d">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="d8c17d37-f783-44f4-b921-c168cdd5e266">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="0d4b384f-6910-44cc-a58a-82de063bf261">
          <SHORT-NAME>Os_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="8e83880e-ea26-401f-badd-9f41d4ea08f4">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="d7341e3b-e5a3-449c-adbb-866b726f00c0">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="7434032d-9b92-4412-9382-a3b66b694995">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="909a8520-e107-4658-9ca0-24a2836c4b32">
          <SHORT-NAME>Dem_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="a5962d96-52fb-46fd-a657-6294fd8dc1e4">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="6fe727d2-5ab6-4da2-8a67-659e21731720">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="4423cefb-44e4-440e-94ff-89fede85b126">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="7ceaa1f3-87ab-4047-a33f-2e1c59aeb2ad">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="22725a6f-8c5d-4fab-9bc6-ab141cb65878">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="71873140-dc0d-4f8e-9391-88d3b098047a">
      <SHORT-NAME>StartApplication</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="88433843-31c8-46f9-bfa6-3812d3e45afb">
          <SHORT-NAME>StartApplication_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="7f74729c-ddde-44f2-b7c6-0bb99beadc4c">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="38B40B18-D2D2-4F5F-B2BC-59D4FE514AB9">
      <SHORT-NAME>VehicleProject</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0319D29B-C79E-4AB5-9014-FCBD776C72FF">
      <SHORT-NAME>Cluster</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C567B09C-7117-4CD5-BCC7-821BB1E3CD05">
      <SHORT-NAME>ECU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="ADDB3203-8AFF-498D-9783-D6B51DC4144B">
      <SHORT-NAME>IPDUGroup</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3E349382-341A-45E2-A836-73EAF5822991">
      <SHORT-NAME>CanFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4273963E-1F10-42B1-A660-01D20646C162">
      <SHORT-NAME>PDU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="5EDB8CDC-7CAA-44F1-9D25-567E19019632">
      <SHORT-NAME>ISignal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="35856EB4-C39C-4626-A17B-C7ACBC9A9405">
      <SHORT-NAME>Signal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="FEA412CB-2093-4607-A19B-FCCD85B218BF">
      <SHORT-NAME>DataType</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="79F4550B-6FFD-4EBD-B2D5-FFDD5E832F89">
          <SHORT-NAME>Semantics</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="04BF0E28-A54B-4A4D-AF33-EE7ACDC26210">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C566A136-A763-43BD-A711-DFC23C4A0FF5">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B3ADF41D-C71B-4F9D-AD0C-3060F27F860A">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A3697616-2116-4705-8E11-F95ED32694F0">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A4E216A7-4CDB-4AB2-94DD-FFD178E6A785">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B931CC0A-0907-4682-8129-8DA4282D0BFF">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C8B55E86-A54D-42AF-9F43-A9BD02EA2E7D">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="26A51BFA-5F52-4CAC-9D40-7EE00495242F">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="AA4586B9-46C1-43C0-BD32-A0006DA117A0">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="221F0CD1-CEC9-4BB7-A182-B35BEF44C204">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="ED3BEF21-8BA0-4808-8035-2E5DCB64DDF8">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="98F7E90F-DE40-410E-B3D2-BA966C2A546F">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="1506D3F8-D88E-4787-8DD5-BF7E9A02245C">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="00F32DDC-F3A9-4AE9-8D72-4478FE66F9D1">
      <SHORT-NAME>Constant</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AA05B1A4-7A6F-4D82-9BF0-0E84325F87E4">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6F593AC2-4F17-43ED-B855-3FB294CA661F">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="E83B5C15-7FE6-4B29-B4A2-0B77376C1254">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7B1F138F-2FED-4E71-B922-E98184D52390">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="0967C37E-6DCD-4A1E-9F25-734205B3C71D">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="124FE2A5-7DBE-45D7-9826-6EC8FCB00193">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7DCA5F0D-1530-482D-98D9-B0F4259A3C13">
          <SHORT-NAME>test</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6E970B97-6F66-41E8-8A94-9990327C687D">
      <SHORT-NAME>Diagnostics</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D0E4BCD4-A9AA-4953-812F-BE2B23DD8235">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="379E76FF-5711-411D-996F-52B75F91CCEE">
      <SHORT-NAME>FlexrayFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D2D44370-310F-4678-9ACE-D645C35F79B3">
      <SHORT-NAME>Gateway</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3CFD1114-8939-451E-BABF-D02A501899D7">
      <SHORT-NAME>LinFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9F74F947-20AB-4208-84A1-3A13C4E2502C">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A4E447BE-30C5-48B6-A0B6-ACE18D8211A1">
      <SHORT-NAME>NM</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="2BBD37F2-E77B-45DA-BB2A-6EF9F3F54547">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="FEC25872-56F0-42E9-B124-936337B2D346">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="02917853-4215-4E51-A014-2819D9A03C57">
      <SHORT-NAME>TP</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>